File: Power_Systems_Complete/cap_tray.kicad_sch (KiCad schematic)
At the start: 17 parts

Commit message: Made changes
Other:
- moved on the sheet: C?
